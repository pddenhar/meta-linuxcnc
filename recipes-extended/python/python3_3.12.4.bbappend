#PACKAGECONFIG:append = " tk"
# The Python recipe is currently broken with a dependency loop when we include Tkinter in the build